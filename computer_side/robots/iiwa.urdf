Commit message: fix velocity bugs

File: computer_side/robots/iiwa.urdf (robot description, URDF)
Before this commit: robot iiwa14, 10 links, 9 joints
Joints:
- joint iiwa_joint_ee: origin xyz=0 0 0.045 rpy=0 0 0 -> xyz=0 0 0.2 rpy=0 0 0
